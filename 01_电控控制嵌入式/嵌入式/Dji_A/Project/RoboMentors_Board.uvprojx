# Keil uVision project RoboMentors_Board.uvprojx, settings and files
target RoboMentors_Board (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RoboMentors_Board +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ..\Inc;..\Inc\hal_inc;..\Inc\m3_inc;..\Inc\os_inc;..\Inc\hal_inc\Legacy;..\User;..\User\algorithm;..\User\app;..\User\driver
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group driver
    ../User/: rm_hal_lib.h
    ../User/driver/: uart_device.c can_device.c can_device.h lingzu_motor.c lingzu_motor.h Movement.c Movement.h leg.c leg.h
  group algorithm
    ../User/algorithm/: pid.c ramp.c
  group app
    ../User/: startup.c
    ../User/app/: study_task.c lingzu_task.c lingzu_task.h uart_task.c uart_task.h
  group custom
    ../User/: sys.h
  group lib
    ../Inc/: stm32f4xx_it.c RoboMentors_Board1_3.lib
  group readme
    ../: README.md
